options:
  parameters:
    author: SP5WWP
    generate_options: qt_gui
    id: test
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: analog_frequency_modulator_fc_0
  id: analog_frequency_modulator_fc
  parameters:
    sensitivity: (2.0*3.1415926535*800.0)/(samp_rate)
  states: {}
- name: analog_frequency_modulator_fc_0_0
  id: analog_frequency_modulator_fc
  parameters:
    sensitivity: (2.0*3.1415926535*800.0)/(samp_rate)
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '115'
    type: float
  states: {state: disabled}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: sample_n2xdd_stream.bin
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '8'
    l: '2'
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: '10'
    type: float
  states: {}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: float
    symbol_table: '[1,3,-1,-3]'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    bw: samp_rate
    fc: '0'
    fftsize: '4096'
    freqhalf: 'False'
    grid: 'True'
    label1: RRC filtered
    label2: Unfiltered
    nconnections: '2'
    type: float
    wintype: window.WIN_BLACKMAN
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    bw: samp_rate
    fc: '0'
    fftsize: '4096'
    freqhalf: 'False'
    grid: 'True'
    label1: M17 RF
    label2: Unfiltered
    nconnections: '2'
    type: complex
    wintype: window.WIN_BLACKMAN
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    legend: 'False'
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: float
    ymax: '5'
    ymin: '-5'
  states: {state: disabled}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: '0.5'
    decim: '10'
    gain: '10'
    interp: '10'
    ntaps: 23*10+1
    samp_rate: '10'
    sym_rate: '1'
    type: interp_fir_filter_fff
  states: {}

connections:
- [analog_frequency_modulator_fc_0, '0', qtgui_freq_sink_x_0_0, '0']
- [analog_frequency_modulator_fc_0_0, '0', qtgui_freq_sink_x_0_0, '1']
- [blocks_file_source_0_0, '0', blocks_repack_bits_bb_0, '0']
- [blocks_repack_bits_bb_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [blocks_repeat_0, '0', analog_frequency_modulator_fc_0_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', blocks_repeat_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', root_raised_cosine_filter_0, '0']
- [root_raised_cosine_filter_0, '0', analog_frequency_modulator_fc_0, '0']

metadata:
  file_format: 1
